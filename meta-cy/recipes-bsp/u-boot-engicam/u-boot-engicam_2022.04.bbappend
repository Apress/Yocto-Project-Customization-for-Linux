DESCRIPTION = "i.MX U-Boot supporting CY (i.MX8) reference boards."

UBOOT_SRC = "git:///home/giometti/yocto/u-boot-engicam-nxp-2022.04/"
SRCBRANCH = "master-cy"
SRCREV = "${AUTOREV}"
