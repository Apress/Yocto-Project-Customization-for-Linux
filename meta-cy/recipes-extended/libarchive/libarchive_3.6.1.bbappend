SRC_URI += "file://CVE-2022-36227.patch;subdir=libarchive-3.6.1"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

